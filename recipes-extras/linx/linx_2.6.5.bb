require linx.inc
LICENSE = "BSD"

PR = "r0"

SRC_URI += " file://liblinx_nobase.patch \
             file://linxcfg_nobase.patch "

LIC_FILES_CHKSUM = "file://COPYING;md5=59530bdf33659b29e73d4adb9f9f6552"
