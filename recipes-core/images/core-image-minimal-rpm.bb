require recipes-core/images/core-image-minimal.bb

DESCRIPTION = "A RPM based small image just capable of allowing a device to boot"
