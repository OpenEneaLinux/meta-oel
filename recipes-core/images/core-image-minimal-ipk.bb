require core-image-minimal.bb

DESCRIPTION = "A IPK based small image just capable of allowing a device to boot"
